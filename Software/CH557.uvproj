# Keil uVision project CH557.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH557 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: CH557 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG
  c include: .\ADC;.\DATAFLASH;.\Public;.\RGB;.\SPI;.\TIMER;.\TOUCHKEY;.\UART;.\USB\USB_LIB;.\USB\Host
  asm include: .\Public
  group main
    ./main/: Debug.C CompositeKM.C CH557.H CH557X.H CH557.INC
